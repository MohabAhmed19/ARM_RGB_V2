# Keil uVision project RGB_V2.0.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: first_p +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\RGB_V2.0;.\APP;.\HAL;.\MCAL;.\SERVICE
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group APP
    ./APP/: main.c
  group MCAL
    ./MCAL/: GPIO.h SysTick_timer.c SysTick_timer.h
  group HAL
    ./HAL/: LED.c LED.h Push_button.c Push_button.h
  group SERVICE
    ./SERVICE/: common.h
software components: CMSIS:CORE 5.3.0, Device:Startup 1.0.1
